# IAR project GD32307C_EVAL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F307xC GD GD32F307xC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F30X_CL
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\GD32F30x_Firmware_Library\GD32F30x_standard_peripheral\Include; ..\..\..\..\..\Utilities; ..\inc; ..\..\..\Third_party\lwip-2.2.1\src\include; ..\..\..\Third_party\lwip-2.2.1\src\include\lwip; ..\..\..\Third_party\lwip-2.2.1\src\include\netif; ..\..\..\Third_party\lwip-2.2.1\port\GD32F30x; ..\..\..\..\..\..\GD32F30x_Firmware_Library\CMSIS\GD\GD32F30x\Include; ..\..\..\Third_party\lwip-2.2.1\port\GD32F30x\Basic
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GD32307C_EVAL.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    ../src/: gd32f30x_enet_eval.c gd32f30x_it.c http_adc_led.c main.c netconf.c
  group CMSIS
    ../src/: system_gd32f30x.c
  group Doc
    ../: readme.txt
  group GD32F30x_EVAL
    ../../../../../Utilities/: gd32f307c_eval.c
  group GD32F30x_Peripherals
    ../../../Third_party/lwip-2.2.1/src/netif/: ethernet.c
    ../../../../../../GD32F30x_Firmware_Library/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Lwip
    ../../../Third_party/lwip-2.2.1/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../Third_party/lwip-2.2.1/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../Third_party/lwip-2.2.1/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Lwip_http
    ../src/: fs.c httpd.c
  group Lwip_port
    ../../../Third_party/lwip-2.2.1/port/GD32F30x/Basic/: ethernetif.c
  group Startup
    ../../../../../../GD32F30x_Firmware_Library/CMSIS/GD/GD32F30x/Source/IAR/: startup_gd32f30x_cl.s

# Keil uVision project GD32307C_EVAL.uvprojx, settings and files
target GD32F307C_EVAL (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F307VC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.3.0
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32307C_EVAL +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_CL
  c include: ..\..\..\..\..\..\GD32F30x_Firmware_Library\GD32F30x_standard_peripheral\Include;..\..\..\..\..\Utilities;..\inc;..\..\..\Third_party\lwip-2.2.1\src\include;..\..\..\Third_party\lwip-2.2.1\src\include\ipv4;..\..\..\Third_party\lwip-2.2.1\src\include\netif;..\..\..\Third_party\lwip-2.2.1\src\include\lwip;..\..\..\Third_party\lwip-2.2.1\port\GD32F30x;..\..\..\Third_party\lwip-2.2.1\port\GD32F30x\Basic;..\..\..\..\..\..\GD32F30x_Firmware_Library\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application
    ../src/: netconf.c main.c http_adc_led.c gd32f30x_it.c gd32f30x_enet_eval.c
  group CMSIS
    ../src/: system_gd32f30x.c
  group GD32F30x_Peripherals
    ../../../../../../GD32F30x_Firmware_Library/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group GD32F30x_EVAL
    ../../../../../Utilities/: gd32f307c_eval.c
  group Startup
    ../../../../../../GD32F30x_Firmware_Library/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_cl.s
  group Lwip
    ../../../Third_party/lwip-2.2.1/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../Third_party/lwip-2.2.1/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c acd.c
    ../../../Third_party/lwip-2.2.1/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../Third_party/lwip-2.2.1/src/netif/: ethernet.c
  group Lwip_port
    ../../../Third_party/lwip-2.2.1/port/GD32F30x/Basic/: ethernetif.c
  group Lwip_http
    ../src/: httpd.c fs.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.5.0
